# Keil uVision project test2lineServo.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F380 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: test_4bit
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c lcd_4bit.c mymain.c init380.c
